# Keil uVision project Pro.uvproj, settings and files
target Target 1 (MCS-51)
  device: HC89S003AF4 HC89S Series
  cpu: IRAM(0-0xFF) XRAM(0-0x2FF) IROM(0-0x3FFF) CLOCK(32000000)
  output: Pro +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\HAEDWARE\soft_timer;..\HAEDWARE\uart_Ringbuf
  group Source Group 1
    ./: STARTUP.A51
    ../user/: main.c
  group HARDWARE
    ../HAEDWARE/soft_timer/: soft_timer.c
    ../HAEDWARE/uart_Ringbuf/: uart_Ringbuf.c
